<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Projects_boot\bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Projects_canhub\canhub.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Projects_input\input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Projects_motor\motor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Projects_qifa\qifa.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>build all debug</name>
      <member>
        <project>bootloader</project>
        <configuration>Debug_CanHub</configuration>
      </member>
      <member>
        <project>bootloader</project>
        <configuration>Debug_Input</configuration>
      </member>
      <member>
        <project>bootloader</project>
        <configuration>Debug_Motor</configuration>
      </member>
      <member>
        <project>bootloader</project>
        <configuration>Debug_Qifa</configuration>
      </member>
      <member>
        <project>canhub</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>input</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>motor</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qifa</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>build all release</name>
      <member>
        <project>bootloader</project>
        <configuration>Releas_Motor</configuration>
      </member>
      <member>
        <project>bootloader</project>
        <configuration>Release_Input</configuration>
      </member>
      <member>
        <project>bootloader</project>
        <configuration>Release_Qifa</configuration>
      </member>
      <member>
        <project>bootloader</project>
        <configuration>Release_CanHub</configuration>
      </member>
      <member>
        <project>input</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>qifa</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>canhub</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>motor</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


