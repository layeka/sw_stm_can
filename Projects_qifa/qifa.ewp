# IAR project qifa.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042x6 ST STM32F042x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_OUTPUT; APP
  ICCARM.CCIncludePath2: ..\common; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; USER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: C300E-SWQF_OUT-APP.bin
  ILINK.IlinkOutputFile: C300E-SWQF_OUT-APP.out
  ILINK.IlinkIcfFile: ..\common\EWARM\stm32f042x6_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F042; USE_DEFAULT_TIMEOUT_CALLBACK; DMP_TYPE_OUTPUT; APP
  ICCARM.CCOptLevel: 3
  prebuild: ..\common\touchVer.bat  USER\
  ILINK.IlinkOutputFile: qifa.out
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f042.s
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group COMMON
    ../common/: algorithm.c algorithm.h anniuled.c anniuled.h boot.c boot.h can.c can.h can_dmp.c can_dmp.h can_wp.h flash id.c flash id.h timer.c timer.h type.h
  group ICF
    ../common/EWARM/: stm32f042x6_app.icf
  group LIB/STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    USER/: cancmd.c cancmd.h Check_Qifa_Res_ADC.c main.c main.h pwm.c pwm.h stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h SWQF_OUTPUT.C swqf_output.h ver.c
